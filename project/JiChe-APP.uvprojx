# Keil uVision project JiChe-APP.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32H474RE Nationstech
  pack: Nationstech.N32H47x_DFP.1.1.0
  cpu: IRAM(0x20000000,0x30000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: JiChe-APP +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=5 wLevel=2
  c define: N32H474, USE_STDPERIPH_DRIVER
  c include: ..\Code\100_MCAL\101_MCU\CMSIS\core;..\Code\100_MCAL\101_MCU\CMSIS\device;..\Code\100_MCAL\101_MCU\n32h47x_48x_std_periph_driver\inc;..\Code\100_MCAL\102_chip;..\Code\200_bsp\201_MCU;..\Code\200_bsp\202_chip;..\Code\300_core;..\Code\500_LibDevelop\501_MCUDevelop;..\Code\500_LibDevelop\502_AFE;..\Code\500_LibDevelop\503_Lib;..\Code\900_user;..\Code\900_user\sci_com;..\Code\900_user\can_com;..\Code\500_LibDevelop\509_para
  library: MicroLIB
  memory RVCT4: ROM 0x8006000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  group 101_MCU/CMSIS/device
    ../Code/100_MCAL/101_MCU/CMSIS/device/: n32h47x_48x_it.c system_n32h47x_48x.c startup_n32h474.s
  group 101_MCU/n32h47x_lib
    ../Code/100_MCAL/101_MCU/n32h47x_48x_std_periph_driver/src/: misc.c n32h47x_48x_adc.c n32h47x_48x_comp.c n32h47x_48x_cordic.c n32h47x_48x_crc.c n32h47x_48x_dac.c n32h47x_48x_dbg.c n32h47x_48x_dma.c n32h47x_48x_dvp.c n32h47x_48x_eth.c n32h47x_48x_exti.c n32h47x_48x_fdcan.c n32h47x_48x_femc.c n32h47x_48x_flash.c n32h47x_48x_fmac.c n32h47x_48x_gpio.c n32h47x_48x_i2c.c n32h47x_48x_iwdg.c n32h47x_48x_lptim.c n32h47x_48x_pga.c n32h47x_48x_pwr.c n32h47x_48x_rcc.c n32h47x_48x_rtc.c n32h47x_48x_sdio.c n32h47x_48x_shrtim.c n32h47x_48x_spi.c n32h47x_48x_tim.c n32h47x_48x_usart.c n32h47x_48x_vrefbuf.c n32h47x_48x_wwdg.c n32h47x_48x_xspi.c
  group 200_bsp/201_MCU
    ../Code/200_bsp/201_MCU/: io_ctrl.c timer.c uart.c wdg.c flash.c spi.c can.c sys_cfg.c pwm.c adc_deal.c
  group 200_bsp/202_chip
    ../Code/200_bsp/202_chip/: EEPROM.c balance.c MP279x_spi.c short_current.c
  group 300_core
    ../Code/300_core/: basic_data_type.h pub_func.c
  group 501_MCUDevelop
    ../Code/500_LibDevelop/501_MCUDevelop/: sys_timer.c io_func.c sys_pwr.c
  group 502_AFE
    ../Code/500_LibDevelop/502_AFE/: AlertInterruptMask.c BrokenLineDetect.c CellBalance.c ChargerDetect.c Current.c Delay.c DVC11XX.c FETControl.c GPn.c I2C.c JiChe_APP.c LoadDetect.c Protection.c Reset.c Shutdown.c Sleep.c Temperature.c Voltage.c
  group 503_Lib
    ../Code/500_LibDevelop/503_Lib/: lib_SOC.lib lib_sleepFunc.c lib_IODrivers.lib
  group 509_para
    ../Code/500_LibDevelop/509_para/: parameter_save_flash.c runtimeData_save_flash.c
  group 900_user
    ../Code/900_user/: data_deal.c main.c Fault.c heat_cool.c log_record.c ProductionID.c sleep_user.c soc_user.c System_Monitor.c CBC.c charger_loader_func.c parameter_save.c drivers_ctrl.c
  group 900_user/sci_com
    ../Code/900_user/sci_com/: sci_com.c uart_client.c uart_upper.c uart_lcd.c
  group 900_user/can_com
    ../Code/900_user/can_com/: can_com.c
